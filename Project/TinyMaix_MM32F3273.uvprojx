# Keil uVision project TinyMaix_MM32F3273.uvprojx, settings and files
target TinyMaix_MM32F3277 (6180000::V6.18::ARMCLANG)
  device: MM32F3273G8P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.6
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TinyMaix_MM32F3277 +hex
  AfterMake: fromelf --bin -o "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\1_Main;..\2_Drivers\Inc;..\3_MM32F327x;..\3_MM32F327x\CMSIS\Include;..\3_MM32F327x\drivers;..\TinyMaix\include;..\TinyMaix\model\mnist;..\TinyMaix\model\cifar;..\TinyMaix\model\mbnet;..\TinyMaix\model\vww96
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\3_MM32F327x\mdk\linker\mm32f3277g_flash.scf
  group App
    ../1_Main/: main.c
  group Drivers
    ../2_Drivers/Src/: drv_led.c drv_sysclk.c drv_systick.c drv_uart.c drv_buffer.c timer.c
  group MM32F327x_Core
    ../3_MM32F327x/mdk/: startup_mm32f3277g.s
    ../3_MM32F327x/: system_mm32f3277g.c
  group MM32F327x_HAL_Driver
    ../3_MM32F327x/drivers/: hal_common.h hal_adc.c hal_comp.c hal_dac.c hal_dma.c hal_exti.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_syscfg.c hal_tim_16b.c hal_tim_32b.c hal_tim_adv.c hal_tim_basic.c hal_uart.c hal_usb.c hal_wwdg.c
  group Tiny_Maix
    ../TinyMaix/: tm_layers.c tm_layers_O1.c tm_model.c tm_stat.c
